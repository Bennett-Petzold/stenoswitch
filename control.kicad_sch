File: control.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Update layout
Parts:
- renumbered BT_EN1 to BT_EN0, STORAGE_EN1 to STORAGE_EN0, TRANSLATION_EN1 to TRANSLATION_EN0
